# Keil uVision project STM_F4_DISCOVERY_SPI_TEST.uvproj, settings and files
target Target 1 (ARM-ADS)
  device: STM32F407VG STMicroelectronics
  cpu: IRAM(0x20000000-0x2001FFFF) IRAM2(0x10000000-0x1000FFFF) IROM(0x8000000-0x80FFFFF) CLOCK(25000000) CPUTYPE("Cortex-M4") FPU2
  output: STM_F4_DISCOVERY_SPI_TEST +hex
  c flags: Optim=1 OneElfS=1
  c misc: --c99
  c include: .\SRC;.\SRC\HARDWARE;..\SRC\LIB\inc;..\SRC\
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x100000
  memory RVCT9: RAM 0x20000000 size 0x20000
  memory RVCT10: RAM 0x10000000 size 0x10000
  group Source Group 1
    ./: startup_stm32f40_41xxx.s
  group SRC
    ./SRC/: main.c
  group SRC_MAX_SPEED
    ./SRC/: SPI_Tets.c
  group LIB
    ../SRC/LIB/src/: misc.c stm32f4xx_adc.c stm32f4xx_can.c stm32f4xx_crc.c stm32f4xx_cryp.c stm32f4xx_cryp_aes.c stm32f4xx_cryp_des.c stm32f4xx_cryp_tdes.c stm32f4xx_dac.c stm32f4xx_dbgmcu.c stm32f4xx_dcmi.c stm32f4xx_dma.c stm32f4xx_exti.c stm32f4xx_flash.c stm32f4xx_fsmc.c stm32f4xx_gpio.c stm32f4xx_hash.c stm32f4xx_hash_md5.c stm32f4xx_hash_sha1.c stm32f4xx_i2c.c stm32f4xx_iwdg.c stm32f4xx_pwr.c stm32f4xx_rcc.c stm32f4xx_rng.c stm32f4xx_rtc.c stm32f4xx_sdio.c stm32f4xx_spi.c stm32f4xx_syscfg.c stm32f4xx_tim.c stm32f4xx_usart.c stm32f4xx_wwdg.c
  group SRC_EX_MAX_SPEED
    ../SRC/: rb_base64m.c rb_crc16.c rb_crcTBL.c rb_fifo.c rb_strnum.c rb_util.c rb_util_ext.c rbSTM32DeviceInfo.c cortex_rb_sys.c
  group HARDWARE
    ./SRC/HARDWARE/: hardware.c
  group HARDWARE_MAX_SPEED
    ./SRC/HARDWARE/: hdadc.c hdfsmc.c hdi2c.c hdi2c_CFG.c hdinterrupt.c hdports.c hdspi.c hdspi_CFG.c hdtimers.c interface.c
